IMAGE_INSTALL:append = " ledhat"
